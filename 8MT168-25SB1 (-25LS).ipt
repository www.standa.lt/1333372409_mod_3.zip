# Autodesk Inventor part: 8MT168-25SB1uzsakovui
## iProperties
Created: 2009-08
Part Number: 8MT168-25SB1uzsakovui
Document SubType Name: Modeling
Designer: Darius
Author: Darius
